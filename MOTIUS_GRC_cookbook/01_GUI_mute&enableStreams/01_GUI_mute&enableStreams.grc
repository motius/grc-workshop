options:
  parameters:
    author: JI
    generate_options: qt_gui
    id: GUI_EnableStreams
    output_language: python
    title: GUI_EnableStreams
  states: {}

blocks:
- name: qtgui_check_box_muteStream
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Toogle mute
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: qtgui_check_box_muteStream
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_mute_xx_0, '0']
- [blocks_mute_xx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
