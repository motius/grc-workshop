options:
  parameters:
    author: JI
    generate_options: qt_gui
    id: TCP_sampleCommunication
    output_language: python
    title: TCP_sampleCommunication
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: '10'
    msg: pmt.intern("TEST")
    std: '100'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: basically a repeater
  states: {state: disabled}
- name: note_0_0
  id: note
  parameters:
    note: Communication over TCP
  states: {state: disabled}
- name: note_1
  id: note
  parameters:
    comment: The lower config represents a real world communication
    note: Real world demo
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: '[0,0]'
    key: input
    label: TX (press 'enter' to send)
    type: string
    value: bla
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: '[0,1]'
    key: input
    label: RX
    type: string
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50252
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://10.6.6.54:50252
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:50252
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://10.6.5.119:50252
    timeout: '100'
  states: {state: disabled}

connections:
- [blocks_message_strobe_random_0, strobe, zeromq_push_msg_sink_0, in]
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_message_strobe_random_0, set_msg]
- [qtgui_edit_box_msg_0, msg, zeromq_push_msg_sink_0, in]
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_pull_msg_source_0, out, qtgui_edit_box_msg_0_0, val]

metadata:
  file_format: 1
