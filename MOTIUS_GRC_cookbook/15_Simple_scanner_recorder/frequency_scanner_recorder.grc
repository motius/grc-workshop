options:
  parameters:
    author: JI
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: scanner_recorder
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    comment: |-
      This selector enables changing the 
      center-frequency of your SDR to search for a signal source
    type: real
    value: 435e6
  states: {}
- name: ip
  id: variable
  parameters:
    comment: |-
      This IP can be used for a network connection
      (PlutoSDR and this machine are in the some network)
    value: '''10.6.7.31'''
  states: {state: disabled}
- name: ip
  id: variable
  parameters:
    comment: |-
      This IP can be used for a direct connection
      (PlutoSDR connected via USB)
    value: '''pluto.local'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: The sampling rate defines the "visibile" scope
    value: 20e6
  states: {}
- name: Info
  id: note
  parameters:
    comment: |-
      In case you want to enable "recording",
      simply enable the file sink on the right!

      The resulting file location will be raltive 
      to where GRC was started at ("./"  is always relative in python)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./ch3/scan_00_c313M_s8M.iq
    type: complex
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(center_freq)
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    uri: ip
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
