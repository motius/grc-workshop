options:
  parameters:
    author: JI
    generate_options: qt_gui
    id: periodMatching
    output_language: python
    title: periodMatching
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: float
  states: {state: bypassed}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int((10e3 /1e3)*2)
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '-1,-1,1,1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repeat_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
