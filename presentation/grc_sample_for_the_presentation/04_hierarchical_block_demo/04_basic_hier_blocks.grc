options:
  parameters:
    author: funki
    description: multiplication via hier-block
    generate_options: hb
    id: demo_hier
    output_language: python
    title: hier_block
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Mult_out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in1
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: second_element
    type: float
  states: {}

connections:
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_1, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
