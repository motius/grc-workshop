options:
  parameters:
    author: funki
    generate_options: qt_gui
    id: simple_demo
    output_language: python
    title: This is the window Name
  states: {}

blocks:
- name: ampl
  id: variable
  parameters:
    value: '.1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '600'
    step: '1'
    stop: '5000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: selector
  id: variable_qtgui_entry
  parameters:
    label: selector
    type: bool
    value: '0'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: ampl/10
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: ampl
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/funki/Desktop/GRC_workshop/03/base_rec.binary
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/funki/Desktop/GRC_workshop/03/noise_rec.binary
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/funki/Desktop/GRC_workshop/03/noise_rec.binary
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: selector
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: (0, 1, 2 ,3)
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_1, '1']
- [analog_noise_source_x_0_0, '0', blocks_file_sink_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0_1, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [blocks_add_xx_0_1, '0', blocks_selector_0, '1']
- [blocks_file_source_0, '0', blocks_add_xx_0_1, '1']
- [blocks_selector_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_file_sink_0, '0']
- [virtual_source_0, '0', audio_sink_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
