options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_cutoff
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: audio_transition
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2400e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 150e3
  states: {}
- name: filePath
  id: variable
  parameters:
    value: '"/home/funki/Desktop/GRC_workshop/06_extra/sample.wav"'
  states: {}
- name: freq_rx
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 98e6
  states: {}
- name: freq_tx
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 2398e6
  states: {}
- name: rfBandwidth
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: source_selector_var
  id: variable_qtgui_chooser
  parameters:
    label: Audio source
    label0: wav-file
    label1: Mic/Line-in
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: '100'
    value: '20'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1e-2'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_tx-center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: working_samp_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(working_samp_rate)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(working_samp_rate)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_selector_var
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: filePath
    repeat: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_rx-center_freq
    decim: int(samp_rate/working_samp_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,channel_width/2,transition_width)
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.0'
    auto_filter: 'True'
    bandwidth: int(rfBandwidth)
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    uri: pluto.local
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(rfBandwidth)
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(center_freq)
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    uri: pluto.local
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: audio_cutoff
    decim: '1'
    gain: '1'
    samp_rate: working_samp_rate
    type: fir_filter_fff
    width: audio_transition
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This represents the channel in this simple  FM-transmission example.
      Right now it is set to a virtual channel.
      In case we have SDR hardware available 
      (namely a PlutoSDR in this case), we can
    note: Channel
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: This reperesent the TX part of our transmission system
    note: TX-blocks
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      This reperesent the RX part of our transmission system.
      On top of acquiring data, a resampling is necessary to actually listen to the stream
    note: RX-blocks
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/working_samp_rate)
    taps: firdes.low_pass(1,samp_rate,channel_width/2,transition_width)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(working_samp_rate/audio_samp_rate)
    taps: firdes.low_pass(1,working_samp_rate,audio_cutoff,audio_transition)
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: int(working_samp_rate)
    interp: '48000'
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', low_pass_filter_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_selector_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [iio_pluto_source_0, '0', virtual_sink_1, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0, '0', iio_pluto_sink_0, '0']
- [virtual_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_1, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
